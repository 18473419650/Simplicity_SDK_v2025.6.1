# Keil uVision project CMSIS_DAP.uvprojx, settings and files
target LPC-Link2 (6160000::V6.16::ARMCLANG)
  device: LPC4370:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.9.0
  cpu: IRAM(0x10000000,0x20000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CMSIS_DAP +hex
  AfterMake: fromelf.exe --bin -o  "$L@L.bin" "#L"
  c flags: Optim=4 uC99=1 v6LangP=3 wLevel=3
  c include: .;..\..\..\Include
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c target.c ser_num.c USBD_User_CustomClass_0.c USBD_User_CDC_ACM_UART_0.c
  group Documentation
    ./: Abstract.txt
  group CMSIS DAP
    ./: DAP_config.h
    ../../../Source/: DAP.c JTAG_DP.c SW_DP.c SWO.c UART.c
target LPC-Link2 on-board (6160000::V6.16::ARMCLANG)
  device: LPC4322:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.9.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x4000) IROM(0x1A000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CMSIS_DAP +hex
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A000000)
  AfterMake: fromelf.exe --bin -o  "$L@L.bin" "#L"
  c flags: Optim=4 uC99=1 v6LangP=3 wLevel=3
  c define: TARGET_POWER_EN LPC_LINK2_ONBOARD
  c include: .;..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, USB:CORE 6.14.1, USB:Device 6.14.1, USB:Device:CDC 6.14.1, USB:Device:Custom Class 6.14.1, CMSIS Driver:USART 2.14, CMSIS Driver:USB Device:USB0 2.12, Device:GPDMA 1.6, Device:SCU 1.1, Device:Startup 1.0.0
